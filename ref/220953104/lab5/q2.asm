	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =N
	LDR R1, [R0]
	BL FACT
	LDR R0, =Result
	STR R1, [R0]
STOP B STOP

FACT
	CMP R1, #1
	BEQ EXIT
	PUSH {R1, LR}
	SUB R1, #1
	BL FACT
EXIT
	POP{R2, LR}
	MUL R1, R2
	BX LR
N DCD 0x5
	AREA mydata, DATA, READWRITE
Result DCD 0
	END