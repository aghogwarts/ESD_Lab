	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R1, #10
	LDR R0, =N
	MOV R4, #0
	LDR R2, =result
UP  LDR R3, [R0, R4]
	STR R3, [R2, R4]
	ADD R4, #4
	SUB R1, #1
	CMP R1, #0
	BHI UP
	MOV R4, #0
	LDR R2, =result
	MOV R1, #9
OUTER_LOOP
	SUB R1, #1
	CMP R1, #0
	BEQ EXIT
	ADD R5, R2, R4
	LDR R8, [R5]
	ADD R4, #4
	MOV R0, #0
INNER_LOOP
	ADD R0, #4
	ADD R0, R4
	ADD R6, R2, R0
	LDR R9, [R6]
	CMP R8, R9
	BLHI SWAP
	CMP R0, #0x24
	BNE INNER_LOOP
	
	
EXIT
	
STOP B STOP

SWAP
	MOV R8, R9
	MOV R5, R6
	BX LR
N DCD 0xA13B4EF8, 0x1C2E34D7, 0xD32E54A6, 0x543A5EBC, 0xABED2A4E, 0x24141245, 0xE196DA4C, 0x9324EAC2, 0x654ECD2A, 0xABCDDEAF
	AREA mydata, DATA, READWRITE
result DCD 0 
	END